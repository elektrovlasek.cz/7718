Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-05-08T07:59:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 08 07:59:48 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{E4A9A379-D928-46F3-AA4A-A0C2878AAB10}\ifc * Database version: 5507 * Database creation date: Wed May 08 07:59:46 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 08 07:59:47 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 08 07:59:47 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21731557_OE1_11109960_G7315SCiXXL_ED, 11109960_OE1_G7315SCiXXL_ED:21731557_OE1_11109960_G7315SCiXXL_ED:207988
In: Level 1
Type - Classification: G7005 (Uniformat); Material: z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21731557_OE1_11109960_G7315SCiXXL_ED
Pset_ManufacturerTypeInformation - Manufacturer: Miele
